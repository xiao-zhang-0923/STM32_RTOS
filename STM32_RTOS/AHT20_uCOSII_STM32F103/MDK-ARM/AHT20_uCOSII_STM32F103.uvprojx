# Keil uVision project AHT20_uCOSII_STM32F103.uvprojx, settings and files
target AHT20_uCOSII_STM32F103 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AHT20_uCOSII_STM32F103 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\Core\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\CMSIS\Include;..\Middlewares\Third_Party\uC-OS2\Source;..\Middlewares\Third_Party\uC-OS2\Cfg;..\Middlewares\Third_Party\uC-OS2\Ports\ARM-Cortex-M3\RealView
  asm define: USE_HAL_DRIVER,STM32F103xB
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c app_tasks.c bsp_led.c stm32f1xx_it.c stm32f1xx_hal_msp.c system_stm32f1xx.c i2c_soft.c aht20.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c
  group Middlewares/uC-OS2/Source
    ../Middlewares/Third_Party/uC-OS2/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Middlewares/uC-OS2/Ports
    ../Middlewares/Third_Party/uC-OS2/Ports/ARM-Cortex-M3/RealView/: os_cpu_c.c os_cpu_a.asm
